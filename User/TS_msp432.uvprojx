# Keil uVision project TS_msp432.uvprojx, settings and files
target TS_msp432 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432.1.0.0
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) IRAM2(0x01000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TS_msp432
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Hardware\Inc;..\Lib\driverlib\MSP432P4xx;..\Lib\inc;..\Lib\inc\CMSIS;..\System\Inc;..\System;..\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group User
    ./: main.c
  group Lib
    ../Lib/driverlib/MSP432P4xx/keil/: msp432p4xx_driverlib.lib
  group Hardware
    ../Hardware/: ADS1292R.c ECG_process.c key.c mygpio.c myspi.c
  group Startup
    ./RTE/Device/MSP432P401R/: system_msp432p401r.c startup_msp432p401r_uvision.s
  group System
    ../System/: mydelay.c myusart.c mysysclk.c
